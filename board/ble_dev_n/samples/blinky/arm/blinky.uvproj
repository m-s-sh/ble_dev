# Keil uVision project blinky.uvproj, settings and files
target thermometer (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: thermometer
  c flags: Optim=1
  c define: NRF51  NRF51822_QFAA_CA MK_TRACE_UART DEBUG_NRF
  c misc: --c99
  c include: ..\..\..\nrf51822_sdk\Include;..\..\..\nrf51822_sdk\Include\ble\softdevice;..\..\..\nrf51822_sdk\Include\app_common;..\..\..\..\..\Include;..\..\..\..\..\Include\mk_trace
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ../src/: main.c dht22.c
    ../../../nrf51822_sdk/Source/app_common/: app_fifo.c
    ../../../nrf51822_sdk/Source/nrf_assert/: nrf_assert.c
  group core
    ../src/: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../nrf51822_sdk/Source/nrf_delay/: nrf_delay.c
    ../../../../../source/mk_trace/: mk_trace.c
